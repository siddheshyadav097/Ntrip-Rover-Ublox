# Keil uVision project vts_dubai.uvprojx, settings and files
target vts_dubai (6180000::V6.18::ARMCLANG)
  device: STM32G0B1RCTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00024000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: vts_dubai_v300 +hex
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32G0B1xx
  c include: ../Core/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;..\debug_log\inc;..\fota\Inc;..\gsm\Inc;..\memory\inc;..\Packeting\Inc;..\qbootloader\inc;..\qtimespent\inc;..\Ring_Buffer\Inc;..\Inc;..\crc16\inc;..\rfid\inc
  memory RVCT4: ROM 0x8004000 size 0x1bfff
  memory RVCT9: RAM 0x20000000 size 0x24000
  group Application/MDK-ARM
    ./: startup_stm32g0b1xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32g0xx_it.c iwdg.c stm32g0xx_hal_msp.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_ll_adc.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_ll_dma.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_iwdg.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_hal_rtc.c stm32g0xx_hal_rtc_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group debug_log
    ../debug_log/src/: debug_log.c debug_log_port.c
  group fota
    ../fota/Src/: fota_api.c
  group gsm
    ../gsm/Src/: ftp_url_decode.c gsm_api.c gsm_at_handler.c gsm_common.c gsm_ftp_api.c gsm_gprs_api.c gsm_idle_task.c gsm_init_cmd.c gsm_port.c gsm_process_resp.c gsm_reset_power.c gsm_sim_api.c gsm_socket_api.c gsm_sms.c gsm_ssl_config.c gsm_statemachine.c gsm_urc_api.c gsm_ufs.c gsm_utility.c
  group memory
    ../memory/src/: mem_config_api.c mem_packet_api.c memorydriver.c memoryport.c qmath.c
  group Packeting
    ../Packeting/Src/: bat_api.c bat_port.c rtc_port.c gps_api.c gps_port.c mbcrc.c packet_api.c dig_ip_handler.c digio_api.c digio_port.c
  group qbootloader
    ../qbootloader/src/: qboot.c qboot_port.c
  group qtimespent
    ../qtimespent/src/: qtimespent.c
  group Ring_Buffer
    ../Ring_Buffer/Src/: ring_buffer.c
  group Src
    ../Src/: ais_app.c led_api.c led_port.c lib_api.c buzzer_app.c
  group crc16
    ../crc16/src/: crc16.c crc24q.c
  group rfid
    ../rfid/src/: rfid_data_handler.c serial_rfid_api.c serial_rfid_port.c
software components: CMSIS:CORE 5.6.0
